# Keil uVision project board_hmi_butterfly.uvprojx, settings and files
target board_hmi_butterfly (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L476ZETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: board_hmi_butterfly +hex
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L476xx
  c misc: --C99
  c include: ../Inc;     ../Drivers/STM32L4xx_HAL_Driver/Inc;     ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;     ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;     ../Drivers/CMSIS/Device/ST/STM32L4xx/Include;     ../Middlewares/Third_Party/FreeRTOS/Source/include;     ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;     ../Drivers/CMSIS/Include;     ..\..\..\common\Inc;     ..\..\..\config\Inc;     ..\..\..\hal\Inc;     ..\..\..\driver\Inc;     ..\..\..\driver\panel\Inc;     ..\..\..\driver\cap touch\Inc;     ..\..\..\driver\tsc\Inc;     ..\..\..\framework\Inc;     ..\..\..\app\proj_hmi_butterfly\Inc;     ..\..\..\app\proj_hmi_butterfly\gui\Inc;     ..\Middlewares\Third_Party\STM32_TouchSensing_Library\inc;     ..\..\..\framework\nvms\Inc
  asm include: ..\Inc;..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: stm32l4xx_it.c stm32l4xx_hal_msp.c freertos.c main.c lcd.c dma.c usart.c gpio.c rtc.c i2c.c spi.c tim.c tsc.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_cortex.c stm32l4xx_hal.c stm32l4xx_hal_gpio.c stm32l4xx_hal_pwr.c stm32l4xx_hal_i2c.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_tim.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_dma.c stm32l4xx_hal_uart.c stm32l4xx_hal_lcd.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_tsc.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: timers.c tasks.c queue.c croutine.c event_groups.c list.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
  group Flex/Common
    ../../../common/Src/: flex_platform.c flex_common.c
  group Flex/Hal
    ../../../hal/Src/: flex_hal.c
  group Flex/Driver
    ../../../driver/Src/: flex_drv.c flex_drv_beeper.c flex_drv_boot.c flex_drv_button.c flex_drv_eint.c flex_drv_led.c flex_drv_seg.c flex_drv_m24cxx.c flex_drv_tlc5947.c
    ../../../driver/panel/Src/: flex_drv_font.c flex_drv_panel.c flex_drv_panel_oled_sh1106_i2c.c flex_drv_panel_stnlcd_jlx128x128_spi.c
    ../../../app/proj_hmi_butterfly/gui/Src/: flex_app_blotter.c
    ../../../driver/tsc/Src/: flex_drv_tsc.c tsl_user.c
    ../../../driver/cap touch/Src/: flex_drv_captouch.c flex_drv_captouch_cap1188.c flex_drv_captouch_cap1214.c flex_drv_captouch_mpr121.c
  group Flex/Framework
    ../../../framework/Src/: flex_framework.c flex_framework_esp32.c flex_framework_input.c flex_framework_privtocol.c
    ../../../framework/nvms/Src/: nvparam.c nvms.c
  group Flex/App
    ../../../app/proj_hmi_butterfly/Src/: flex_app.c flex_app_segdisp.c flex_app_nvparam.c
  group Flex/App/Gui
    ../../../app/proj_hmi_butterfly/gui/Src/: flex_app_logo.c flex_app_blotter_menu.c flex_app_osd_global.c flex_app_osd_string.c flex_app_osd_user.c flex_app_osd_func.c flex_app_osd_menutbl.c flex_app_osd_draw.c flex_app_osd_menu.c flex_app_osd_application.c
  group Middleware/STM32_TouchSensing_Lib
    ../Middlewares/Third_Party/STM32_TouchSensing_Library/src/: tsl.c tsl_acq.c tsl_acq_tsc.c tsl_dxs.c tsl_ecs.c tsl_filter.c tsl_globals.c tsl_linrot.c tsl_object.c tsl_time.c tsl_touchkey.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
software components: CMSIS:CORE 4.1.0
